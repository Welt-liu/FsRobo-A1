Commit message: save

File: src/robo_5dof/robo_description/urdf/robo_description.urdf (robot description, URDF)
Before this commit: robot robo_description, 8 links, 7 joints
Joints:
- joint hand_joint: limit lower=-0.5 upper=3.1 effort=30 velocity=50 -> lower=-3.1 upper=3.1 effort=30 velocity=50
